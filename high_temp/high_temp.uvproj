# Keil uVision project high_temp.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: high_temp +hex
  AfterMake: fromelf.exe --bin -o high_temp.bin ./output/high_temp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../../ingchips_sdk/ING_SDK/sdk/bundles/typical/inc;../../../ingchips_sdk/ING_SDK/sdk/bundles/typical/inc/os;../../../ingchips_sdk/ING_SDK/sdk/src/BSP;../../../ingchips_sdk/ING_SDK/sdk/src/FWlib;../../../ingchips_sdk/ING_SDK/sdk/src/StartUP/ing916;../../../ingchips_sdk/ING_SDK/sdk/src/Tools;../../../ingchips_sdk/ING_SDK/sdk/src
  library: MicroLIB
  memory RVCT4: ROM 33726464 size 352256
  memory RVCT9: RAM 536892432 size 11248
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../../ingchips_sdk/ING_SDK/sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../../../ingchips_sdk/ING_SDK/sdk/src/BSP/: eflash.c
  group FWlib
    ../../../ingchips_sdk/ING_SDK/sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../../../ingchips_sdk/ING_SDK/sdk/src/Tools/: trace.c
