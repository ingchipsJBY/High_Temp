# Keil uVision project high_temp.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: high_temp +hex
  AfterMake: fromelf.exe --bin -o high_temp.bin ./output/high_temp.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../../../ingchips_sdk/ING_SDK/sdk/bundles/typical/inc;../../../ingchips_sdk/ING_SDK/sdk/bundles/typical/inc/os;../../../ingchips_sdk/ING_SDK/sdk/src/BSP;../../../ingchips_sdk/ING_SDK/sdk/src/FWlib;../../../ingchips_sdk/ING_SDK/sdk/src/StartUP/ing916;../../../ingchips_sdk/ING_SDK/sdk/src/Tools;../../../ingchips_sdk/ING_SDK/sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x202a000 size 0x56000
  memory RVCT9: RAM 0x20005410 size 0x2bf0
  group APP
    ./src/: main.c profile.c
  group KvFlash
    ./src/: kv_impl.c kv_flash.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../../ingchips_sdk/ING_SDK/sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../../../ingchips_sdk/ING_SDK/sdk/src/BSP/: eflash.c
  group FWlib
    ../../../ingchips_sdk/ING_SDK/sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../../../ingchips_sdk/ING_SDK/sdk/src/Tools/: trace.c
    D:/ingchips_sdk/ING_SDK/sdk/src/Tools/: ad_parser.c
software components: CMSIS:CORE 4.3.0
